# Keil uVision project Tsf411.uvprojx, settings and files
target Tsf411 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Tsf411 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../DISPLAY/Target;../Drivers/BSP/Components/TSC2046;../Drivers/BSP/Components/ili9341;../Drivers/BSP/Components/Common;../Middlewares/Third_Party/lvgl;../Middlewares/Third_Party/lvgl/src;../Middlewares/Third_Party/lvgl/src/core;../Middlewares/Third_Party/lvgl/src/draw;../Middlewares/Third_Party/lvgl/src/draw/arm2d;../Middlewares/Third_Party/lvgl/src/draw/nxp/pxp;../Middlewares/Third_Party/lvgl/src/draw/nxp/vglite;../Middlewares/Third_Party/lvgl/src/draw/renesas;../Middlewares/Third_Party/lvgl/src/draw/sdl;../Middlewares/Third_Party/lvgl/src/draw/stm32_dma2d;../Middlewares/Third_Party/lvgl/src/draw/sw;../Middlewares/Third_Party/lvgl/src/draw/swm341_dma2d;../Middlewares/Third_Party/lvgl/src/extra;../Middlewares/Third_Party/lvgl/src/extra/layouts;../Middlewares/Third_Party/lvgl/src/extra/layouts/flex;../Middlewares/Third_Party/lvgl/src/extra/layouts/grid;../Middlewares/Third_Party/lvgl/src/extra/libs;../Middlewares/Third_Party/lvgl/src/extra/libs/bmp;../Middlewares/Third_Party/lvgl/src/extra/libs/ffmpeg;../Middlewares/Third_Party/lvgl/src/extra/libs/freetype;../Middlewares/Third_Party/lvgl/src/extra/libs/fsdrv;../Middlewares/Third_Party/lvgl/src/extra/libs/gif;../Middlewares/Third_Party/lvgl/src/extra/libs/png;../Middlewares/Third_Party/lvgl/src/extra/libs/qrcode;../Middlewares/Third_Party/lvgl/src/extra/libs/rlottie;../Middlewares/Third_Party/lvgl/src/extra/libs/sjpg;../Middlewares/Third_Party/lvgl/src/extra/libs/tiny_ttf;../Middlewares/Third_Party/lvgl/src/extra/others;../Middlewares/Third_Party/lvgl/src/extra/others/fragment;../Middlewares/Third_Party/lvgl/src/extra/others/gridnav;../Middlewares/Third_Party/lvgl/src/extra/others/ime;../Middlewares/Third_Party/lvgl/src/extra/others/imgfont;../Middlewares/Third_Party/lvgl/src/extra/others/monkey;../Middlewares/Third_Party/lvgl/src/extra/others/msg;../Middlewares/Third_Party/lvgl/src/extra/others/snapshot;../Middlewares/Third_Party/lvgl/src/extra/themes;../Middlewares/Third_Party/lvgl/src/extra/themes/basic;../Middlewares/Third_Party/lvgl/src/extra/themes/default;../Middlewares/Third_Party/lvgl/src/extra/themes/mono;../Middlewares/Third_Party/lvgl/src/extra/widgets;../Middlewares/Third_Party/lvgl/src/extra/widgets/animimg;../Middlewares/Third_Party/lvgl/src/extra/widgets/calendar;../Middlewares/Third_Party/lvgl/src/extra/widgets/chart;../Middlewares/Third_Party/lvgl/src/extra/widgets/colorwheel;../Middlewares/Third_Party/lvgl/src/extra/widgets/imgbtn;../Middlewares/Third_Party/lvgl/src/extra/widgets/keyboard;../Middlewares/Third_Party/lvgl/src/extra/widgets/led;../Middlewares/Third_Party/lvgl/src/extra/widgets/list;../Middlewares/Third_Party/lvgl/src/extra/widgets/menu;../Middlewares/Third_Party/lvgl/src/extra/widgets/meter;../Middlewares/Third_Party/lvgl/src/extra/widgets/msgbox;../Middlewares/Third_Party/lvgl/src/extra/widgets/span;../Middlewares/Third_Party/lvgl/src/extra/widgets/spinbox;../Middlewares/Third_Party/lvgl/src/extra/widgets/spinner;../Middlewares/Third_Party/lvgl/src/extra/widgets/tabview;../Middlewares/Third_Party/lvgl/src/extra/widgets/tileview;../Middlewares/Third_Party/lvgl/src/extra/widgets/win;../Middlewares/Third_Party/lvgl/src/font;../Middlewares/Third_Party/lvgl/src/hal;../Middlewares/Third_Party/lvgl/src/misc;../Middlewares/Third_Party/lvgl/src/widgets;../Middlewares/Third_Party/lvgl/porting;../Middlewares/Third_Party/lvgl/demos;../Middlewares/Third_Party/lvgl/demos/stress;../Middlewares/Third_Party/lvgl/demos/widgets
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: display_app.c main.c gpio.c freertos.c spi.c tim.c custom_bus.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/DISPLAY/Target
    ../DISPLAY/Target/: lcd_os.c lcd_io.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/TSC2046/: tsc2046.c
    ../Drivers/BSP/Components/ili9341/: ili9341.c ili9341_reg.c
  group lvgl/porting
    ../Middlewares/Third_Party/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl/src/core
    ../Middlewares/Third_Party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/Third_Party/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
  group lvgl/src/extra
    ../Middlewares/Third_Party/lvgl/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/Third_Party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl/src/extra/layouts/flex/: lv_flex.c
  group lvgl/src/misc
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../Middlewares/Third_Party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/src/hal
    ../Middlewares/Third_Party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/font
    ../Middlewares/Third_Party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/demos
    ../Middlewares/Third_Party/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
software components: CMSIS:CORE 4.3.0
